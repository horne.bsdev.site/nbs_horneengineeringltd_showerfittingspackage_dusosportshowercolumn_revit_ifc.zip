Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-10-11T07:58:36
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220517_1515(x64) - Exporter 20.2.90.12 - Alternate UI 20.2.90.12
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Oct 11 07:58:36 2023 * Host: BIMServices * Database: C:\Users\PIOTRB~1\AppData\Local\Temp\f417ea85-6b6b-487b-86c9-a28277fa1a04\d815b57d-767c-4881-b2ab-4569ce334458\ifc * Database version: 5507 * Database creation date: Wed Oct 11 07:58:36 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Oct 11 07:58:36 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Oct 11 07:58:36 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm

# IfcBuilding
COBie - Category: Project Information

# IfcBuildingStorey: Level:Circle Head - Project Datum, Level 0
LongName: Level 0; Elevation: 0 mm
COBie - Category: Levels; Name: Level 0

# IfcDistributionPort, Port_316166
Description: Flow; FlowDirection: SOURCE

# IfcFlowTerminal: DusoAquamarineTrimDSA60A, NBS_HorneEngineeringLtd_ShwrFitngsPckge_DusoSportShowerColumn:DusoAquamarineTrimDSA60A:316166
In: Level 0
Type - PredefinedType: SHOWER; Material: NBS_HorneEngineeringLtd_Grey, NBS_HorneEngineeringLtd_Aquamarine, NBS_HorneEngineeringLtd_AnodisedAluminium, NBS_HorneEngineeringLtd_Chrome
Type - BOS_General - Author: NBS; BIMObjectName: NBS_HorneEngineeringLtd_ShowerFittingsPackage_DusoSportShowerColumn_DusoAquamarineTrimDSA60A; ManufacturerName: Horne Engineering Ltd; ManufacturerURL: www.horne.co.uk; ProductInformation: https://source.thenbs.com/product/-/50f25428-06b5-40f8-9d16-253e255fa2f0/ecee50a0-f59d-421c-ac0f-fd6ead395bdd; Uniclass2015Title: Shower fittings package; Uniclass2015Code: Pr_40_20_87_75; Uniclass2015Version: Products v1.31; Version: 1
Type - NBS_Data - Accessory: Duŝo multi-tool, P/N 21-6071; Approvals: UK Water Regulation 4 Approved; Connection: Mixed (pre-blended) supply only, top entry inlet, 15 mm compression; CountryOfProductManufacture: United Kingdom; FlowRateMaximum: 8 L/min; Form: Wall-mounted shower column with fixed vandal resistant shower head and push paddle timed flow control; MaterialsBody: Aluminium and plastics; MaterialsFinishAndColour: Anodized column, chromium-plated shower head, aquamarine trim; Recyclability: Can be recycled; WaterSupplyTemperatureMaximum: 41°C
Type - IFC - IfcExportAs: IfcSanitaryTerminalType; IfcExportType: SHOWER
COBie - AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_40_20_87_75:Shower fittings package; CodePerformance: n/a; Color: Grey,Blue,Yellow,Black; Constituents: n/a; Description: A shower column for group showering applications; DurationUnit: year; ExpectedLife: n/a; Features: Robust construction, finish and fittings for extended lifespan, vandal resistant shower head with two spray positions and easy clean nozzle array; Finish: Anodized,Chrome,Smooth; Grade: n/a; Manufacturer: specifications@horne.co.uk; Material: Aluminium,Plastic,Brass; ModelNumber: DS-A60A; ModelReference: Duŝo Sport Shower Column; Name: ShowerFittingsPackage_DusoSportShowerColumn_DusoAquamarineTrimDSA60A_HorneEngineeringLtd; NominalHeight: 1176 mm; NominalLength: 0 mm; NominalWidth: 56 mm; ReplacementCost: n/a; Shape: Other; Size: 56 x 158 x 1176 mm; SustainabilityPerformance: Integral 8 L/min flow regulator; WarrantyDescription: Two year; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
